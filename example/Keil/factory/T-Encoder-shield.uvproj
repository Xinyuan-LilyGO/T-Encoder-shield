# Keil uVision project T-Encoder-shield.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH554 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: CH552 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\USB\Device;.\USB\Device;.\GPIO;.\SPI;.\UART1
  group Source Group 1
    ./Public/: Debug.C
    ./user/: main.c
    ./GPIO/: GPIO.C
    ./SPI/: SPI.C
